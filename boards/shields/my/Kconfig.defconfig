## boards/shields/my/Kconfig.defconfig
```kconfig
if SHIELD_MY

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "My"

endif
```
